# Repository jpskenn/Sandy

File README.md:

# Sandy（サンディ）

Sandy is a keyboard with key height optimization.

Layered PCB will make height differences for each key.
This covers the lack of optimization to physical key layout that only adjust x-y direction in a plane.

---

Sandyは、スイッチの配置を立体的にして高さ方向への最適化を加えた、左右対称レイアウトの60%キーボードです。  

平面上のキーレイアウトだけでは最適化しきれない部分を、キーの位置に応じてスイッチを配置する高さを変えることで補っています。

名前の由来は、立体的、つまり3Dという意味を込めて…

``` text
3D → スリーディー → さんディー → サンディ → Sandy
```

という言葉遊びで、Sandy（サンディ）に決まりました。

---

## お知らせ

2023-11-04

キー割り当て書き換えツール[Remap](https://remap-keys.app)がQMKファームウェアのバージョン 0.22.2以降に対応したことに伴い、新しくビルドしたSandyのファームウェアを公開しました。  
参考：[Remap supports QMK Firmware 0.22.2 or higher](https://remap-keys.app/docs/support-qmk-022)

今すぐファームウェアを更新する必要はありませんが、ロータリーエンコーダへのキー割り当てを変更したい場合は、ファームウェアを更新するとよいでしょう。

Remapによる旧バージョンのサポート終了後は、ファームウェアを更新してください。

詳しくは、ビルドガイドの「Sandy関連ファイル」等をご覧ください。

## 特徴

- 左右対称のキーレイアウト  
  [Jones](https://github.com/jpskenn/Jones)と同様の、2行目と3行目にずれのない、左右対称な、シンメトリカル ロースタッガードのレイアウトです。

- キースイッチを立体的に配置  
  3段階の高さで、キースイッチを立体的に配置しています。

  平面上のキー配置だけでは最適化しきれない部分を、キーの位置に応じて高さを変え、立体的に配置することで補っています。  
  Jonesに比べて、ホームポジションから遠いキーへの打鍵しやすさが向上しています。

- 60%ケースと組み合わせられる  
  GH60型ケース互換のネジ穴を用意してあるので、市販のケースと組み合わせて使用できます。  
  ※詳しくはビルドガイドを参照

- [Remap](https://remap-keys.app)や[VIA](https://www.caniusevia.com)によるキー割り当て変更  
  プログラミング等の知識がなくても、ブラウザ上で簡単にキー割り当てを変更することができます。

- 外部EEPROM搭載  
  Remapでたくさんのレイヤーを使用できます。

- オプション機能  
  以下のオプション機能を使用できます。

  - ロータリーエンコーダ
  - インジケータLED
  - アンダーグローLED

## レイアウト

### バリエーション

キーのバリエーションを含むレイアウトは以下の通りです。  
Ctrl（左）とEnter（右）にはキーサイズのバリエーションがあり、最下行の中央にはロータリーエンコーダを配置できます。
[  
Keyboard Layout Editor: Sandy (DN0030)](http://www.keyboard-layout-editor.com/#/gists/c907e866d8f82b82a22b455e622b7301)

### キーの高さ

キーの高さはLow（0mm）, Middle（3.6mm）, High（8.6mm）の3段階で、以下のように配置されます。  

### 推奨キーマッピング

このレイアウトは、左右の手の運指を同じにするため、[SemiErgo Layout](https://github.com/mtei/SemiErgo_Layout)に準ずるキーマッピングで使用することを念頭に設計されています。  
つまり、一般的なロースタッガードレイアウトから、アルファ部の左手側Z行を左へ1キー、数字行の右手側を右側へ1キーずらしたものが、推奨キーマッピングとなります。

以下にSemiErgoを適用した推奨キーマッピングの例を示します。  
枠で囲った部分が、一般的なロースタッガードからの変更箇所です。

<small>💡ヒント：このキーマッピング例ではスペースキーをSandS（Space & Shift）にしているので、左右端のシフトキーを取り除いています。</small>

## ビルドガイド

- 最新版
  - [Sandy（DN0030）](/docs/BuildGuide_DN0030.md)

- 試作版
  - [Sandy（DN0020）](/docs/BuildGuide_DN0020.md)
  - [Sandy v.0.1](/docs/BuildGuide_v0_1.md)

## SNSタグ

[#Sandy_kbd](https://twitter.com/search?q=%23Sandy_kbd)

## ギャラリー

v.0.1, Cherryプロファイルキーキャップ使用  

v.0.1, KATプロファイルキーキャップ使用

キーの段差（Cherryプロファイル）

キーの段差（KATプロファイル）

キーの段差（横）

## 残る課題

Sandyは複数基板を重ねるという手法で製作しているため、その技術的な制限や、製作工程を複雑にしすぎない配慮により、全てのスイッチをなめらかな高さ変化で配置できていません。  
そのため、高さ方向へ最適化しきれていない部分が残っています。  

## 参考事例

- [Genesis2.5](https://github.com/sekigon-gonnoc/Genesis2.5-doc)（[販売ページ](https://booth.pm/ja/items/1308005)  
  行ごとに高さと傾きを変えることができる自作キーボードキット。  

- [Thumbs Up!](https://www.thumbsup.shop)  
  カラムスタガをベースに親指や中央のキーを高くした設計の自作キーボードキット。

- [Kinesis Advantage series](https://kinesis-ergo.com/products/#keyboards)  
  ”エルゴノミクス”、”3Dキーボード”と言えばこれが思い浮かぶのはこれ。凹形状にキーが配置されている。

- [Microsoft Sculpt](https://www.microsoft.com/en/accessories/products/keyboards/sculpt-ergonomic-desktop)  
  ほんのり放射状に並んだキーと、中央部が高くなった形状。

- [Dactyl](https://github.com/adereth/dactyl-keyboard)  
  3Dプリンタで作る、スイッチを3D配置したキーボード。

- ["3D" キーキャップ](https://qiita.com/zk_phi/items/5680607118516413a0ba)  
  キーボードはそのままに、キーごとに高さを変えた3D形状のキーキャップ。MXスイッチ用。

- [Gravity Keycaps](https://note.com/yfuku_/n/n1fbba2e8f44c)  
  Choc用の3D形状キーキャップ。

## 開発経緯

### 元々の計画

当初（2021年1月ごろ）は、Chocスイッチを使用するキーボード、[Nora](https://github.com/jpskenn/Nora)の打鍵しやすさ向上を目的に、スイッチの配置を立体的に改修する計画でした。  
Choc用キーキャップには、行ごとに高さの異なるプロファイルのものが存在しません。すべてのキーが同じ形状になっているため、1行目の数字行や、ホームポジションから遠いキーへ指が届きにくくなります。  
その状況を改善するための改修計画でしたが、あまりモチベーションも上がらず、手をつけずに放置していました。  

### Sandy計画の始動

2022年12月の末ごろ、[SMKJのアドベントカレンダー](https://scrapbox.io/self-made-kbds-ja/アドベントカレンダー)を久しぶりに読み返しながら、様々なアイデアや取り組みについて思いをめぐらせていました。
そのとき、ふとした思いつきでJonesのキーキャップを部分的に背の高いものに入れ替えたところ、思いのほか打鍵しやすくなることに気がつきました。  

奥：通常のJones，手前：一部のキーを入れ替えたJones

Cherryプロファイルをベースにして、`T` `Y`は倍ほどの高さのSAプロファイル、`G`や`Q`などは少しだけ背の高いKATプロファイルに交換しました。  
この時点では`左右のシフト`などをOEMプロファイルでほんの少し高くしようとしていますが、後にボツとなります。

これをきっかけとして、MXスイッチを使用するキーボード、[Jones](https://github.com/jpskenn/Jones)を改修する計画として復活することになりました。  

### ロードテスト

先ほどのテスト機を使い部分的にキーキャップを交換してどのキーを最適化の対象にするかを調べたり、スチレンボードにスイッチをのせたモックアップを作成して最適な高さを探ったりしました。（`0+2+2`は、ベースの0mmに対して、1段目が2mm、2段目も2mmの段差を意味するメモ）

テスト機は、数字行をSAプロファイルへ、また、`T` `Y`をSAプロファイル1行目のキーに交換してさらに高くした最終形態になりました。  

この形態をロードテストとして3ヶ月ほど使用し、日常的な使用で問題ないことを確認した上で基板の製作に取り掛かりました。

## KiCad design PCB/Sandy_Top/Sandy_Top.kicad_pcb

Board: 2 copper layers, 285.0 x 75.1 mm, 29 parts (13 on the bottom side), 14 nets, no tracks yet.

Parts:
D15, D16, D17, D18, D19, D20: D; D_SOD-123_Emphasized_Direction_Line
EXT_TC3, EXT_TC4: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
EXT_TR0, EXT_TR1, EXT_TR4, EXT_TR5: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
H2, H3, H6, H8, H9, H10, H11, H12: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
J2, J3: Conn_02x02_Top_Bottom; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal_wCable_hou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
SW_'1, SW_'1#2: SW_Push; Kailh_socket_ChocV2
SW_;1: SW_Push; Kailh_socket_ChocV2
SW_T1: SW_Push; Kailh_socket_ChocV2
SW_Y1: SW_Push; Kailh_socket_ChocV2
SW_[1: SW_Push; Kailh_socket_ChocV2
SW_]1: SW_Push; Kailh_socket_ChocV2

Connections:
GND: H10.1, J3.3
unnamed: D15.2 (A), SW_;1.2
unnamed: D16.2 (A), SW_T1.2
unnamed: D17.2 (A), SW_[1.2
unnamed: D18.2 (A), SW_]1.2
unnamed: D19.2 (A), SW_Y1.2
unnamed: D20.2 (A), SW_'1#2.2
Top_col2: H6.1, J3.2, SW_T1.1
Top_col3: EXT_TC3.1, H2.1, J3.4, SW_'1#2.1, SW_;1.1, SW_[1.1, SW_]1.1
Top_col4: EXT_TC4.1, H3.1, J3.1, SW_Y1.1
Top_row0: D17.1 (K), D19.1 (K), EXT_TR0.1, H11.1, J2.1
Top_row1: D15.1 (K), EXT_TR1.1, H12.1, J2.4
Top_row4: D16.1 (K), D18.1 (K), EXT_TR4.1, H9.1, J2.2
Top_row5: D20.1 (K), EXT_TR5.1, H8.1, J2.3

## KiCad design PCB/Sandy_Base/Sandy_Base.kicad_pcb

Parts:
C1, C2: 10u; C_1206_3216Metric; LCSC C77090
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C101, C102, C103, C104: 100n; C_0402_1005Metric; LCSC C1525
C13, C16, C17: 2.2uF; C_0402_1005Metric; LCSC C307418
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35: D; D_SOD-123_Emphasized_Direction_Line_Reference_on_bottom; LCSC C109203
D99: PRTR5V0U2X; SOT-143; LCSC C78442
EXT_C0, EXT_C1, EXT_C2, EXT_C3, EXT_C4, EXT_C5, EXT_C6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
EXT_R0, EXT_R1, EXT_R2, EXT_R3, EXT_R4, EXT_R6, EXT_R7: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
F1: Fuse; Fuse_0603_1608Metric; LCSC C187605
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_2.2mm_M2_No_Cu
H_mid_1, H_mid_2, H_mid_3, H_mid_4, H_mid_5, H_mid_6, H_mid_7, H_mid_8, H_mid_9, H_mid_10, H_mid_11, H_mid_12, H_mid_13, H_mid_14, H_mid_15, H_mid_16: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
J1, J2, J3, J4, J5, J6: Conn_02x02_Top_Bottom; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal_wCable_hou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; LCSC C371510
J7: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J8: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical_All_circle
J9: Conn_01x08_Pin; PinHeader_1x08_P1.00mm_Vertical_All_circle
J11: Conn_02x02_Odd_Even; PinHeader_2x02_P2.00mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1, L2, L3, L4: SK6812MINI-E; YS-SK6812MINI-E_middle_hole_with_small_pad
LOGO1: Logo_Base; Sandy_logo_w60_new
LS1, LS2: Speaker; Buzzer_Murata_PKMCS0909E; LCSC C910763
Q1: BSS138; SOT-23; LCSC C78284
R1, R2: 5.1k; R_0402_1005Metric; LCSC C25905
R5, R8, R10, R11, R12, R13, R14: 1k; R_0402_1005Metric; LCSC C11702
R6, R7: 27; R_0402_1005Metric; LCSC C25100
R9: 10k; R_0402_1005Metric; LCSC C25744
RE_Base1: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11K-Switch_Vertical_H20mm_NPTH_MP_mini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
SD1: Schottky diode; D_SOD-123; LCSC C8598
STLED1: LED_GREEN; LED_0402_1005Metric; LCSC C130723
SW1: BOOT; SW_SPST_PTS810; LCSC C92589
SW2: RESET; SW_SPST_PTS810; LCSC C92589
SW_/1: SW_Push; Kailh_socket_ChocV2
SW_;1: SW_Push; Kailh_socket_ChocV2
SW_<1: SW_Push; Kailh_socket_ChocV2
SW_>1: SW_Push; Kailh_socket_ChocV2
SW_A1: SW_Push; Kailh_socket_ChocV2
SW_B1: SW_Push; Kailh_socket_ChocV2
SW_C1: SW_Push; Kailh_socket_ChocV2
SW_CTL1: SW_Push; Kailh_socket_ChocV2
SW_D1: SW_Push; Kailh_socket_ChocV2
SW_E1: SW_Push; Kailh_socket_ChocV2
SW_ENT1: SW_Push; Kailh_socket_ChocV2
SW_F1: SW_Push; Kailh_socket_ChocV2
SW_I1: SW_Push; Kailh_socket_ChocV2
SW_J1: SW_Push; Kailh_socket_ChocV2
SW_K1: SW_Push; Kailh_socket_ChocV2
SW_L1: SW_Push; Kailh_socket_ChocV2
SW_LALTu1: SW_Push; Kailh_socket_ChocV2
SW_LSPC1: SW_Push; Kailh_socket_ChocV2
SW_LWIN1: SW_Push; Kailh_socket_ChocV2
SW_M1: SW_Push; Kailh_socket_ChocV2
SW_N1: SW_Push; Kailh_socket_ChocV2
SW_O1: SW_Push; Kailh_socket_ChocV2
SW_R5CNT_C1, SW_R5CNT_L1, SW_R5CNT_R1: SW_Push; Kailh_socket_ChocV2
SW_RALT1: SW_Push; Kailh_socket_ChocV2
SW_RSPC1: SW_Push; Kailh_socket_ChocV2
SW_RWIN1: SW_Push; Kailh_socket_ChocV2
SW_S1: SW_Push; Kailh_socket_ChocV2
SW_V1: SW_Push; Kailh_socket_ChocV2
SW_W1: SW_Push; Kailh_socket_ChocV2
SW_X1: SW_Push; Kailh_socket_ChocV2
SW_Z1: SW_Push; Kailh_socket_ChocV2
U1: NCP1117-3.3_SOT223; SOT-223-3_TabPin2; LCSC C347222
U2: RP2040; RP2040-QFN-56; LCSC C2040
U3: W25Q128JVPIQ; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; LCSC C190862
Y1: 12MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm; MFR.Part # CSTNE12M0G550000R0; LCSC C341520

Connections:
+1V1: C3.1, C4.1, C16.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C2.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C17.1, JP1.1 (A), Q1.1 (G), R9.1, R11.2, U1.2 (VO), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_IN), U2.48 (USB_VDD), U2.49 (IOVDD), U3.8 (VCC)
+5V: C1.1, C101.2, C102.2, C103.2, C104.2, L1.1 (VDD), L2.1 (VDD), L3.1 (VDD), L4.1 (VDD), R12.2, SD1.1 (K), U1.3 (VI)
Audio1: D34.1 (K), R13.2, U2.31 (GPIO20)
Audio2: D35.1 (K), R14.2, U2.13 (GPIO10)
D+: D99.2 (I/O1), J7.A6 (D+), J7.B6 (D+), R6.2
D-: D99.3 (I/O2), J7.A7 (D-), J7.B7 (D-), R7.2
GPIO0: J9.1, U2.41 (GPIO29_ADC3)
GPIO3: J9.2, U2.40 (GPIO28_ADC2)
GPIO4: J9.3, U2.39 (GPIO27_ADC1)
GPIO5: J9.4, U2.17 (GPIO14), U2.38 (GPIO26_ADC0)
GPIO14: U2.30 (GPIO19)
GPIO26: J9.5, U2.37 (GPIO25)
GPIO27: J9.6, U2.36 (GPIO24)
GPIO28: J9.7, U2.35 (GPIO23)
GPIO29: J9.8, U2.34 (GPIO22)
LED_D_3V3: Q1.2 (S), R11.1, U2.32 (GPIO21)
LED_D_5V: L1.4 (DIN), Q1.3 (D), R12.1
unnamed: D1.2 (A), SW_W1.2
unnamed: D2.2 (A), SW_E1.2
unnamed: D3.2 (A), SW_I1.2
unnamed: D4.2 (A), SW_O1.2
unnamed: D5.2 (A), SW_CTL1.2
unnamed: D6.2 (A), SW_A1.2
unnamed: D7.2 (A), SW_S1.2
unnamed: D8.2 (A), SW_D1.2
unnamed: D9.2 (A), SW_F1.2
unnamed: D10.2 (A), SW_J1.2
unnamed: D11.2 (A), SW_K1.2
unnamed: D12.2 (A), SW_L1.2
unnamed: D13.2 (A), SW_;1.2
unnamed: D14.2 (A), SW_ENT1.2
unnamed: D15.2 (A), SW_Z1.2
unnamed: D16.2 (A), SW_X1.2
unnamed: D17.2 (A), SW_C1.2
unnamed: D18.2 (A), SW_V1.2
unnamed: D19.2 (A), SW_B1.2
unnamed: D20.2 (A), SW_N1.2
unnamed: D21.2 (A), SW_M1.2
unnamed: D22.2 (A), SW_<1.2
unnamed: D23.2 (A), SW_>1.2
unnamed: D24.2 (A), SW_/1.2
unnamed: D25.2 (A), SW_LWIN1.2
unnamed: D26.2 (A), SW_LALTu1.2
unnamed: D27.2 (A), SW_LSPC1.2
unnamed: D28.2 (A), SW_R5CNT_L1.2
unnamed: D29.2 (A), RE_Base1.S1, SW_R5CNT_C1.2
unnamed: D30.2 (A), SW_R5CNT_R1.2
unnamed: D31.2 (A), SW_RSPC1.2
unnamed: D32.2 (A), SW_RALT1.2
unnamed: D33.2 (A), SW_RWIN1.2
unnamed: J7.A5 (CC1), R1.1
unnamed: J7.B5 (CC2), R2.1
unnamed: JP1.2 (B), R5.2
unnamed: L1.2 (DOUT), L2.4 (DIN)
unnamed: L2.2 (DOUT), L3.4 (DIN)
unnamed: L3.2 (DOUT), L4.4 (DIN)
unnamed: LS1.1, R13.1
unnamed: LS2.1, R14.1
unnamed: R8.1, Y1.3
unnamed: F1.2, SD1.2 (A)
unnamed: R5.1, STLED1.2 (A)
unnamed: R7.1, U2.46 (USB_DM)
unnamed: R6.1, U2.47 (USB_DP)
unnamed: U2.20 (XIN), Y1.1
unnamed: R8.2, U2.21 (XOUT)
QSPI_SCLK: U2.52 (QSPI_SCLK), U3.6 (CLK)
QSPI_SD0: U2.53 (QSPI_SD0), U3.5 (DI(IO0))
QSPI_SD1: U2.55 (QSPI_SD1), U3.2 (DO(IO1))
QSPI_SD2: U2.54 (QSPI_SD2), U3.3 (IO2)
QSPI_SD3: U2.51 (QSPI_SD3), U3.7 (IO3)
QSPI_SS: R9.2, R10.2, U2.56 (QSPI_SS), U3.1 (~CS)
RESET: J11.3, SW2.1, U2.26 (RUN)
RE_Base1_A: RE_Base1.A, U2.15 (GPIO12)
RE_Base1_B: RE_Base1.B, U2.14 (GPIO11)
SWCLK: J8.1, U2.24 (SWCLK)
SWD: J8.3, U2.25 (SWD)
USB_BOOT: J11.1, R10.1, SW1.1
VBUS: D99.4 (VCC), F1.1, J7.A4 (VBUS), J7.A9 (VBUS), J7.B4 (VBUS), J7.B9 (VBUS)
row4: D2.1 (K), D4.1 (K), EXT_R4.1, U2.16 (GPIO13)

Notes on the sheet:
SCREWS to Mid
コネクタとネジはWIP
Mid_GNDを仮につけている
SCREWS to Bottom Plate
Speaker
Virtual Connection
Bottom to Mid: require 16 pins Mid to Top: require 13 pins
Panel CONNECTOR Base to Middle
44PIN
USB
LOGO
45PIN
Reserved pins
Base to Top
LED
ERCチェックで、 TopとMidのラベルが見つからないのはOK。 （別プロジェクトでやる）
KEY MATRIX, Base plate
Max keys = 10 rows * 8 cols = 80 Physical keys = 15 + 14 + 14 + 15 + 13 = 71 5-way nav = 5 Remap/VIA virtual key assign for 2 encoders = 2 * 2 = 4 Balance = 0 (!)

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
Board: 2 copper layers, 285.0 x 95.1 mm, 167 parts (118 on the bottom side), 94 nets.

## KiCad design PCB/Sandy_Middle/Sandy_Middle.kicad_pcb

Board: 2 copper layers, 285.0 x 73.4 mm, 70 parts (42 on the bottom side), 27 nets, no tracks yet.

Parts:
Cutout1: 60_Outline; 60_Outline-Sandy-DN0040-Mid
D1, D2, D3, D4, D5, D6, D7, D9, D11, D12, D13: D; D_SOD-123_Emphasized_Direction_Line
EXT_MC0, EXT_MC1, EXT_MC2, EXT_MC3, EXT_MC4, EXT_MC5, EXT_MC6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
EXT_MR0, EXT_MR1, EXT_MR2, EXT_MR3, EXT_MR5, EXT_MR6, EXT_MR7, EXT_MR8: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
H_top_1, H_top_2, H_top_3, H_top_4, H_top_5, H_top_6, H_top_7, H_top_8, H_top_9, H_top_10, H_top_11, H_top_12, H_top_13: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
J1, J2, J3: Conn_02x02_Top_Bottom; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal_wCable_hou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
SW_BS1: SW_Push; Kailh_socket_ChocV2
SW_G1: SW_Push; Kailh_socket_ChocV2
SW_H1: SW_Push; Kailh_socket_ChocV2
SW_P1: SW_Push; Kailh_socket_ChocV2
SW_Q1: SW_Push; Kailh_socket_ChocV2
SW_R1, SW_R4CNT_C1, SW_R4CNT_L1, SW_R4CNT_R1: SW_Push; Kailh_socket_ChocV2
SW_TAB1: SW_Push; Kailh_socket_ChocV2
SW_U1: SW_Push; Kailh_socket_ChocV2

Connections:
Mid_GND: H12.1, H_top_10.1, J2.4
Mid_col0: EXT_MC0.1, H1.1, H_top_1.1, J1.4, SW_Q1.1, SW_TAB1.1
Mid_col1: EXT_MC1.1, H9.1, H_top_6.1
Mid_col2: EXT_MC2.1, H7.1, H_top_7.1, J3.2, SW_G1.1, SW_R1.1, SW_R4CNT_L1.1
Mid_col3: EXT_MC3.1, H3.1, H_top_2.1, J3.4, SW_H1.1, SW_R4CNT_C1.1
Mid_col4: EXT_MC4.1, H4.1, H_top_3.1, J1.2, SW_R4CNT_R1.1, SW_U1.1
Mid_col5: EXT_MC5.1, H8.1, H_top_8.1
Mid_col6: EXT_MC6.1, H6.1, H_top_4.1, J2.2, SW_BS1.1, SW_P1.1
Mid_row0: EXT_MR0.1, H11.1, H_top_5.1
Mid_row1: D1.1 (K), D3.1 (K), D5.1 (K), EXT_MR1.1, H2.1, H_top_11.1, J3.1
Mid_row2: EXT_MR2.1, H13.1, H_top_13.1, J1.1
Mid_row3: D12.1 (K), D13.1 (K), EXT_MR3.1, H15.1, J2.1
Mid_row5: EXT_MR5.1, H10.1, H_top_9.1
Mid_row6: D2.1 (K), D4.1 (K), D6.1 (K), EXT_MR6.1, H5.1, H_top_12.1, J3.3
Mid_row7: D7.1 (K), D9.1 (K), EXT_MR7.1, H14.1, J1.3
Mid_row8: D11.1 (K), EXT_MR8.1, H16.1, J2.3
unnamed: D1.2 (A), SW_TAB1.2
unnamed: D2.2 (A), SW_Q1.2
unnamed: D3.2 (A), SW_R1.2
unnamed: D4.2 (A), SW_U1.2
unnamed: D5.2 (A), SW_P1.2
unnamed: D6.2 (A), SW_BS1.2
unnamed: D7.2 (A), SW_G1.2
unnamed: D9.2 (A), SW_H1.2
unnamed: D11.2 (A), SW_R4CNT_L1.2
unnamed: D12.2 (A), SW_R4CNT_C1.2
unnamed: D13.2 (A), SW_R4CNT_R1.2

## KiCad design PCB/Sandy_Top_with_Plate_Mid/Sandy_Top_with_Plate_Mid.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: D; D_SOD-123_Emphasized_Direction_Line; LCSC C81598
EXT_TC0, EXT_TC1, EXT_TC2, EXT_TC3, EXT_TC4, EXT_TC5, EXT_TC6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
EXT_TR0, EXT_TR1, EXT_TR2, EXT_TR5, EXT_TR6: Conn_01x01; TestPoint_THTPad_D2.0mm_Drill1.0mm
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13: MountingHole; MountingHole_2.2mm_M2_Pad_minimal
J1, J2, J3: Conn_02x02_Top_Bottom; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal_wCable_hou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; LCSC C371510
SW_1, SW_3, SW_5, SW_7, SW_8, SW_9: SW_Push; MXOnly-1U-Hotswap-guide
SW_2, SW_10: SW_Push; MXOnly-1U-Hotswap-screw-hole-side3-guide
SW_4: SW_Push; MXOnly-1U-Hotswap-screw-hole-side1-guide
SW_6: SW_Push; MXOnly-1U-Hotswap-screw-hole-side2-guide
SW_'1: SW_Push; MXOnly-1U-Hotswap-guide
SW_-1: SW_Push; MXOnly-1U-Hotswap-screw-hole-side3-guide
SW_;1: SW_Push; MXOnly-1U-Hotswap-guide
SW_=1: SW_Push; MXOnly-1U-Hotswap-guide
SW_ESC1: SW_Push; MXOnly-1U-Hotswap-guide
SW_INS1: SW_Push; MXOnly-1U-Hotswap-screw-hole-side1-guide
SW_T1: SW_Push; MXOnly-1U-Hotswap-guide
SW_Y1: SW_Push; MXOnly-1U-Hotswap-guide
SW_[1: SW_Push; MXOnly-1U-Hotswap-guide
SW_]1: SW_Push; MXOnly-1U-Hotswap-guide

Connections:
unnamed: D1.2 (A), SW_ESC1.2
unnamed: D2.2 (A), SW_1.2
unnamed: D3.2 (A), SW_2.2
unnamed: D4.2 (A), SW_3.2
unnamed: D5.2 (A), SW_4.2
unnamed: D6.2 (A), SW_5.2
unnamed: D7.2 (A), SW_-1.2
unnamed: D8.2 (A), SW_=1.2
unnamed: D9.2 (A), SW_6.2
unnamed: D10.2 (A), SW_7.2
unnamed: D11.2 (A), SW_8.2
unnamed: D12.2 (A), SW_9.2
unnamed: D13.2 (A), SW_10.2
unnamed: D14.2 (A), SW_INS1.2
unnamed: D15.2 (A), SW_;1.2
unnamed: D16.2 (A), SW_T1.2
unnamed: D17.2 (A), SW_[1.2
unnamed: D18.2 (A), SW_]1.2
unnamed: D19.2 (A), SW_Y1.2
unnamed: D20.2 (A), SW_'1.2

Notes on the sheet:
Connector from Middle
SCREWS to Mid
Bottom to Mid: require 16 pins Mid to Top: require 13 pins
以下の Panel CONNECTOR は、Baseからコピペ。 ERCの警告「別パネルのラベルがどこにも接続されていない」は、無視してOK。 ！！！他の警告（ラベルかぶりとか）は、しっかりチェックせよ！！！
Panel CONNECTOR Base to Middle
TopへはGNDも送りたいが、ピンが足りない。
row2はMidで使用していないが、ピンが余っているので追加。
Virtual Connection
コピペ手順 1. Baseの回路図から "Panel CONNECTOR" の箇所をまるごとコピペ 2. Baseのコネクタのリファレンスの頭に "#" をつけて仮想シンボル化 例： J6 → #J6
Key Matrix
4個目のコネクタは実際に配置していないのでダミー
Mid to Top: require 13 pins ( = 5 row + 7 col + GND )
Base to Top

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
Board: 2 copper layers, 285.0 x 75.1 mm, 68 parts (35 on the bottom side), 32 nets.

File PCB/Sandy_Middle/Sandy_Middle_BOM.csv:

Comment,Designator,Footprint,LCSC
"D","D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13","locallib:D_SOD-123_Emphasized_Direction_Line","C81598"
"Conn_01x01","EXT_MC0,EXT_MR1,EXT_MC2,EXT_MR2,EXT_MC3,EXT_MR3,EXT_MC4,EXT_MC6,EXT_MR6,EXT_MC7,EXT_MR7,EXT_MR8","TestPoint:TestPoint_THTPad_D2.0mm_Drill1.0mm",""
"MountingHole","H1,H2,H3,H4,H5,H6,H7,H8,H9,H10,H11,H12,H13,H14,H15,H16,H17,H18,H19","locallib:MountingHole_2.2mm_M2_Pad_minimal",""
"Conn_02x02_Top_Bottom","J1,J2,J3","locallib:JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal_wCable_housing_spare_pin","C160404"
"SW_Push","SW_'1,SW_;1,SW_G1,SW_H1,SW_P1,SW_Q1,SW_R1,SW_U1,SW_R4CenterC1,SW_R4CenterL1,SW_R4CenterR1","MX_Alps_Hybrid:MXOnly-1U-Hotswap-guide",""
"SW_Push","SW_BS1.5u1,SW_TAB1.5u1","MX_Alps_Hybrid:MXOnly-1.5U-Hotswap-guide",""
